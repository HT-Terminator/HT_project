# Keil uVision project template.uvprojx, settings and files
target Template (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HT32F52342_64LQFP Holtek
  pack: Holtek.HT32_DFP.1.0.44
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52352_SK, USE_HT32F52342_52, USE_MEM_HT32F52352
  c include: ..\Code;..\Code\Include;..\Library\inc;..\Config;..\Utilities\common;..\Hardware\LED;..\Hardware\USART;..\Utilities;..\Utilities\HT32_Board;..\Hardware\PWM;..\Hardware\DELAY;..\Hardware\HX711;..\Hardware\MatrixKey;..\Hardware\OLED;..\Hardware\ISD1820;..\Hardware\ENCODER;..\Hardware\PID;..\Hardware\TIM;..\Hardware\TRACK;..\Hardware\Cloud;..\Hardware\MQTT
  asm define: USE_HT32_CHIP=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ./: ht32f5xxxx_01_it.c main.c
  group Hardware
    ../Hardware/USART/: usart.c
    ../Hardware/PWM/: pwm.c
    ../Hardware/DELAY/: delay.c
    ../Hardware/HX711/: hx711.c
    ../Hardware/MatrixKey/: MatrixKey.c
    ../Hardware/OLED/: oled.c
    ../Hardware/ISD1820/: isd1820.c
    ../Hardware/ENCODER/: encoder.c
    ../Hardware/PID/: pid.c
    ../Hardware/TIM/: timdelay.c
    ../Hardware/TRACK/: track.c
    ../Hardware/Cloud/: Cloud.c
    ../Hardware/MQTT/: MQTT.c
  group Config
    ../Config/: ht32_board_config.h ht32_op.s HT32F5xxxx_01_DebugSupport.ini ht32f5xxxx_01_usbdconf.h ht32f5xxxx_conf.h startup_ht32f5xxxx_01.s
  group Code
    ../Code/: ht32_usbd_core.c system_ht32f5xxxx_01.c
  group Library
    ../Library/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_i2s.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sci.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c
  group Utilities
    ../Utilities/: ht32_board.c ht32_retarget.c ht32_serial.c
    ../Utilities/common/: i2c_eeprom.c
  group Doc
    ../Doc/: readme.txt
